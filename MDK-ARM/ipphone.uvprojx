# Keil uVision project ipphone.uvprojx, settings and files
target ipphone (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ipphone
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;   ../Middlewares/Third_Party/LwIP/src/include;   ../Middlewares/Third_Party/LwIP/system;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Middlewares/Third_Party/LwIP/src/include/lwip;   ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;   ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;   ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;   ../Middlewares/Third_Party/LwIP/src/include/netif;   ../Middlewares/Third_Party/LwIP/src/include/posix;   ../Middlewares/Third_Party/LwIP/src/include/posix/sys;   ../Middlewares/Third_Party/LwIP/system/arch;   ../Drivers/CMSIS/Include;   ../Hardware/Appsys;   ../Hardware/usart;   ../Hardware/delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: eui64.c lcp.c ipcp.c magic.c vj.c chap-new.c ccp.c ecp.c ppp.c upap.c ipv6cp.c pppapi.c fsm.c mppe.c utils.c auth.c multilink.c demand.c chap_ms.c pppol2tp.c eap.c pppcrypt.c pppoe.c chap-md5.c pppos.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c sys.c tcp_out.c udp.c netif.c memp.c dns.c raw.c def.c tcp.c timeouts.c inet_chksum.c init.c ip.c stats.c mem.c pbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/api/: sockets.c netifapi.c tcpip.c err.c netdb.c netbuf.c api_msg.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: mld6.c ip6_frag.c icmp6.c nd6.c ip6_addr.c ethip6.c dhcp6.c inet6.c ip6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4.c ip4_addr.c etharp.c ip4_frag.c icmp.c igmp.c dhcp.c
  group Application/User
    ../Src/: ethernetif.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c MyUDP.c dil_phone.c phone_process.c
  group Hardware
    ../Hardware/usart/: AppUSART.c
    ../Hardware/delay/: AppDelay.c
software components: CMSIS:CORE 4.3.0
